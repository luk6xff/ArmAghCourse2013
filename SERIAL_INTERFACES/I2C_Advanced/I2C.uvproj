# Keil uVision project I2C.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: I2C +hex
  c flags: Optim=1
  c misc: --gnu
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s command_decoder.c dacMcp4921.c keyboard.c led.c main.c mcp23S09.c spi.c string.c timer_interrupts.c uart.c command_decoder.h dacMcp4921.h keyboard.h led.h mcp23S09.h spi.h string.h timer_interrupts.h uart.h i2c.c pcf8574.c mc24lc64.c
