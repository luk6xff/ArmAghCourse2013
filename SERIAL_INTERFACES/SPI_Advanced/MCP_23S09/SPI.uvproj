# Keil uVision project SPI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SPI +hex
  c flags: Optim=1
  c misc: --gnu
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s keyboard.c led.c main.c keyboard.h led.h spi.c timer_interrupts.c timer_interrupts.h dacMcp4921.c command_decoder.h string.h uart.h command_decoder.c string.c uart.c mcp23S09.c
