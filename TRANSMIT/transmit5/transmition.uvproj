# Keil uVision project transmition.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: transmition +hex
  c flags: Optim=1
  c misc: --gnu
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s command_decoder.c keyboard.c led.c main.c servo.c string.c timer_interrupts.c uart.c command_decoder.h keyboard.h led.h servo.h string.h timer_interrupts.h uart.h watch.c
